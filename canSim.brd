# Repository jake-b/CanBusSimulator

File README.md:

# CanBusSimulator
3-Bus CAN Simulator. Optimized for ease of assembly from breakout boards.

This thing probably only solves my problems.  I don't expect it to be of much
use to anyone else.

This is a 3-Bus CAN Bus Simulator designed to help me with the development of
[tesLAX](https://teslax.app).

While I could make this much smaller, I wanted to assemble it quickly without
stencils or surface mount.  Hence it is built from readily available
breakout boards.

It is still under development.  Final design and source code to follow.

# BOM

- ESP32 - a Node32s or equivalent.  Make sure to get a 30-pin version that
matches the PCB silkscreen.
- MCP2515 - CAN Bus Transceiver Breakout Boards.  These are intended to mount
to the top of the main PCB with the headers installed to the underside of
the breakout board.
- MicroSD Breakout - with all the pins not just the SPI ones.  Designed with
this board in mind: https://www.aliexpress.com/item/32787519908.html
- I2C OLED - a 128x64 OLED of the typical type.  Note that these come with
various pinouts, so hopefully you (and I both) get the same pinout as this
main PCB expects.  Also it is intended to be mounted upside-down using a 
right angle header.
- Encoder - again, intended to be mounted upside down with right angle 
headers.  Designed for this PCB: https://www.aliexpress.com/item/4001242057510.html
- DC Power Jack - had some extra space, so why not?  Designed to accept
this breakout board: https://www.aliexpress.com/item/32677142070.html
- Level Shifter - a typical cheap level shifter of the type outlined on the
main PCB.
- 12v Step Up - to power accessories connected to the OBD-2 port, which 
is a 12v source.  With Enable.  Designed with this one in mind: https://www.aliexpress.com/item/32902463323.html
- OBD-2 FEMALE Right Angle Connector - hard to find.  Originnally looking at
one like like this:
https://www.macchina.cc/catalog/parts/obd2-female-right-angle-pth-connector
but I found that http://www.med-obd.com/ has female right angle connectors
of a slightly differnet pinout at a better value.

# Links

Schematic [PDF](schematic.pdf)

## EAGLE design canSim.brd

Parts:
H1, H2, H3, H4, H5: MOUNT-HOLE2.8; 2,8
R1, R2: 10k; 0207/2V
T1: 2N3904; TO92
U$1: ESP32DEVKITV1; ESP32-DEVKITV1
U$2, U$3, U$4: MCP2515_BREAKOUT
U$5: CLEAP_LEVEL_SHIFTER; CHEAP_LEVEL_SHIFTER
U$6: CHEAP_12_BOOSTCHEAP_12_BOOST_VERT; CHEAP_12V_BOOST_VERT
U$7: 128X64_SQUARE; 128X64_SQUARE_VERT
U$8: CHEAP_MICRO_SD
U$9: OBD_2FEMALEOBD2_FEMALE_PTH; OBD2_FEMALE_PTH
U$10: ROTARY_ENC; CHEAP_ENCODER_VERT
U$11: CHEAP_POWER_JACK

Connections:
12V_EN: R1.1, U$1.D26 (IO26)
+3V3: U$1.3V3, U$5.P$10 (LV), U$7.VCC (3V3), U$8.VCC, U$10.VCC
+5V: R2.2, U$1.VIN, U$2.P$7 (VCC), U$3.P$7 (VCC), U$4.P$7 (VCC), U$5.P$4 (HV), U$6.P$1 (VIN), U$11.5V
+12V: U$6.P$4 (VOUT), U$9.12V
CAN1_N: U$2.CAN_L, U$9.CAN1L
CAN1_P: U$2.CAN_H, U$9.CAN1H
CAN2_N: U$3.CAN_L, U$9.CAN2L
CAN2_P: U$3.CAN_H, U$9.CAN2H
CAN3_N: U$4.CAN_L, U$9.CAN3L
CAN3_P: U$4.CAN_H, U$9.CAN3H
COLL: R2.1, T1.1 (C), U$6.P$2 (EN)
CS1: U$1.D5 (IO5), U$2.P$5 (CS)
CS2: U$1.D32 (IO32), U$3.P$5 (CS)
CS3: U$1.D33 (IO33), U$4.P$5 (CS)
ENC_A: U$1.D17 (IO17), U$10.SA
ENC_B: U$1.D16 (IO16), U$10.SB
ENC_BTN: U$1.D25 (IO25), U$10.SW
GND: T1.3 (E), U$1.GND@1 (GND), U$1.GND@2 (GND), U$2.P$6 (GND), U$3.P$6 (GND), U$4.P$6 (GND), U$5.P$3 (GND), U$5.P$9 (GND), U$6.P$3 (GND), U$7.GND, U$8.GND, U$9.GND@1, U$9.GND@2, U$10.GND, U$11.GND@1 (GND), U$11.GND@2 (GND)
INT1_3V3: U$1.D35 (IO35), U$5.P$12 (LV1)
INT1_5: U$2.P$1 (INT), U$5.P$6 (HV1)
INT2_3V3: U$1.D34 (IO34), U$5.P$11 (LV2)
INT2_5: U$3.P$1 (INT), U$5.P$5 (HV2)
INT3_3V3: U$1.D39 (VN-IO39), U$5.P$8 (LV3)
INT3_5: U$4.P$1 (INT), U$5.P$2 (HV3)
MISO_3V3: U$1.D19 (IO19), U$5.P$7 (LV4)
MISO_5: U$2.P$4 (SO), U$3.P$4 (SO), U$4.P$4 (SO), U$5.P$1 (HV4)
MOSI: U$1.D23 (IO23), U$2.P$3 (SI), U$3.P$3 (SI), U$4.P$3 (SI)
unnamed: R1.2, T1.2 (B)
SCK: U$1.D18 (IO18), U$2.P$2 (SCK), U$3.P$2 (SCK), U$4.P$2 (SCK)
SCL: U$1.D22 (IO22), U$7.SCL
SDA: U$1.D21 (IO21), U$7.SDA
SD_CD: U$1.D27 (IO27), U$8.CDN
SD_CLK: U$1.D14 (IO14), U$8.SCLK
SD_CMD: U$1.D15 (IO15), U$8.DI (DI/CMD)
SD_DAT0: U$1.D2 (IO2), U$8.D0 (D0/DAT0)
SD_DAT1: U$1.D4 (IO4), U$8.DAT1
SD_DAT2: U$1.D12 (IO12), U$8.DAT2
SD_DAT3: U$1.D13 (IO13), U$8.CS (CS/CD/DAT3)

Board: 2 copper layers, 100.0 x 83.8 mm, 19 parts (0 on the bottom side), 38 nets.

## Commit log

2020-12-23 fixed file extension in readme
2020-12-23 fixed file extension for real this time.
2021-01-01 New revision with new OBD-2. Auto PCB routing to still change.
2021-01-02 board file
2021-01-04 Release candidate
2021-01-20 Minor tweaks - moved connector. Shifter hole size.
    Moved connector down a little for better fit with the real connector.
    Bigger holes for the 3.3v-5v level shifter so you can use real headers.
2021-01-22 Swap interrupt and CS pins because some ESP32 pins are input-only.
2021-01-22 Very rough test software.
2021-02-09 Updated README.
2021-02-09 Cleaning up the libraries and getting the mcp2515 library local to this repo

Notices in the files:
canSim.brd:
(c)2020-2021 J. Bordens
